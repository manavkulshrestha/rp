Commit message: dl generated

File: pybullet_ur5_robotiq/urdf/objects/thin_cuboid.urdf (robot description, URDF)
Before this commit: robot box.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=0.06 0.025 0.01; visual box size=0.06 0.025 0.01
