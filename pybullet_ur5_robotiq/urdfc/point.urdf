Commit message: Implemented trimesh recreation code. need to fix centeres

File: pybullet_ur5_robotiq/urdfc/point.urdf (robot description, URDF)
Before this commit: robot point, 1 links, 0 joints
Links:
- link _name: mass 0.0 -> 1.0
